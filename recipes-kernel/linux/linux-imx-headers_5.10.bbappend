
require linux-imx-common.inc

SUMMARY = "Installs SRG-IM8P specific kernel headers"
DESCRIPTION = "Installs SRG-IM8P specific kernel headers to userspace. \
New headers are installed in ${includedir}/imx."
